# Keil uVision project plantLeds-BLE.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51422_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DEBUG_LEDS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG  NRF_LOG_USES_RTT=1  BLE_STACK_SUPPORT_REQD   NRF51422   NRF_SD_BLE_API_VERSION=2  S130  NRF51  SOFTDEVICE_PRESENT
  c include: ./;.\Source;.\Source\ble
  asm define: __STARTUP_CONFIG
  asm misc: --cpreproc
  asm include: .\Source\config
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001e10 size 0x21f0
  group Application
    ./Source/: main.c faults.c leds.c
  group BLE
    ./Source/ble/: bleConn.c bleServices.c bleService_password_time.c bleService_leds.c
  group Config
    ./Source/: stdAfx.h trace.h
    ./Source/config/: boardConfig.h startup_config.h ble_password.h
target Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51422_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: plantLeds.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD  NRF51422  NRF_SD_BLE_API_VERSION=2  S130  NRF51  SOFTDEVICE_PRESENT
  c include: ./;.\Source;.\Source\ble;.\Source\ecoe;.\Source\config
  asm define: __STARTUP_CONFIG
  asm misc: --cpreproc
  asm include: .\Source\config
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001e10 size 0x21f0
software components: CMSIS:CORE 5.0.0, Device:Startup 8.11.1, nRF_BLE:BLE_Modules:ble_advdata 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_advertising 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_common 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_conn_params 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_conn_state 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_date_time 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_db_discovery 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_service_common 4.0.0-2.alpha, nRF_BLE:BLE_Modules:device_manager 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_dis 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_lbs 4.0.0-2.alpha, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_drv_common 4.0.0-2.alpha, nRF_Drivers:nrf_drv_wdt 4.0.0-2.alpha, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_wdt 4.0.0-2.alpha, nRF_Drivers:pstorage 4.0.0-2.alpha, nRF_Libraries:app_error 4.0.0-2.alpha, nRF_Libraries:app_timer 4.0.0-2.alpha, nRF_Libraries:app_util 4.0.0-2.alpha, nRF_Libraries:nordic_common 4.0.0-2.alpha, nRF_Libraries:nrf_assert 4.0.0-2.alpha, nRF_Libraries:nrf_log 4.0.0-2.alpha, nRF_Libraries:sdk_mapped_flags 4.0.0-2.alpha, nRF_Libraries:segger_rtt 1.2.1-2.alpha, nRF_SoftDevice:Internal:sd_common 2.0.0-2.alpha, nRF_SoftDevice:Internal:softdevice_in_use 2.0.0-2.alpha, nRF_SoftDevice:Internal:softdevice_present 2.0.0-2.alpha, nRF_SoftDevice:s130 2.0.0-7.alpha
